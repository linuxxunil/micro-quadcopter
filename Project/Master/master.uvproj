# Keil uVision project master.uvproj, settings and files
target Quadcopter (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: master
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\FreeRTOS\include;..\..\HAL\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ../../Source/: main.c startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../../Libraries/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../Libraries/FreeRTOS/portable/ARM_CM3/: port.c
    ../../Libraries/FreeRTOS/portable/MemMang/: heap_1.c
  group HAL
    ../../HAL/src/: led.c motor.c
